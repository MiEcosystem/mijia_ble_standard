# Keil uVision project mijia_app_authen.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prox_reporter_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: CUSTOMIZED_MI_CONFIG_FILE=<custom_mi_config.h> MI_LOG_ENABLED
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr;..\..\..\portable;..\..\..\..\..\mijia_ble_libs\common;..\src\user;..\..\..\..\..\mijia_ble_libs;..\;..\..\..\..\..\..\mijia_ble_standard;..\src\custom_profile
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=prox_reporter_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/workspace/DA14531/test/6.0.12.1020//third_party/rand/: chacha20.c
    C:/workspace/DA14531/test/6.0.12.1020//third_party/hash/: hash.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/syscntl/: syscntl.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/gpio/: gpio.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/battery/: battery.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/dma/: dma.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/uart/: uart.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/i2c/: i2c.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/trng/: trng.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/rtc/: rtc.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/driver/timer/: timer1.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/core_modules/crypto/: aes_api.c sw_aes.c
  group sdk_ble
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/rwble/: rwble.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/profiles/: prf.c prf_utils.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    ../../../../../../../../../sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../../../../../sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    ../../../../../../../../../sdk/ble_stack/host/att/attm/: attm_db_128.c
  group sdk_app
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/workspace/DA14531/test/6.0.12.1020//sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../../../../../sdk/app_modules/src/app_custs/: app_customs.c app_customs_common.c app_customs_task.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_proxr.c
    ../src/user/: user_mijia_ble.c
  group mijia_ble_libs/standard_auth
    ../../../../../mijia_ble_libs/standard_auth/: stand-auth-cortex-m0plus.lib
  group mijia_ble_libs/common
    ../../../../../mijia_ble_libs/common/: crc32.c mible_beacon.c mible_crypto.c mible_rxfer.c queue.c tlv.c
  group mijia_ble_libs/crypto
    ../../../../../mijia_ble_libs/cryptography/: mi_crypto.c mi_crypto_backend_mbedtls.c mi_crypto_backend_uECC.c
  group mijia_ble_libs/third_party
    ../../../../../mijia_ble_libs/third_party/mbedtls/: asn1parse.c ccm.c sha256_hkdf.c
    ../../../../../mijia_ble_libs/third_party/pt/: pt_misc.c
  group mijia_ble_libs/mijia_profiles
    ../../../../../mijia_ble_libs/mijia_profiles/: mi_service_server.c
    ../../../../../mijia_ble_libs/: mi_config.c
  group mijia_ble_api
    ../../../portable/: app_mijia.c app_mijia_task.c cassert.c easy_msg.c easy_nvds.c easy_timer.c mi_app_customs.c mible_api.c mijia.c mijia_task.c sdk_supplement.c user_default_handlers.c da14585_api.c
  group custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: prox_reporter_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr;C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=prox_reporter_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: prox_reporter_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__ CUSTOMIZED_MI_CONFIG_FILE=<custom_mi_config.h> MI_LOG_ENABLED
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr;C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr;C:\workspace\DA14531\test\6.0.12.1020\\sdk\app_modules\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\em;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\lld;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\controller\llm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\ea\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\em\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\hci\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\attm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\att\atts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gap\gapm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\gatt\gattm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\l2c\l2cm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\host\smp\smpm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anc\ancc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\anp\anps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\basc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bas\bass\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bcs\bcss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\blp\blps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\bms\bmss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cpp\cpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cscp\cscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\cts\ctss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\custom\custs\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\disc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\dis\diss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\find\findt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\glp\glps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\hrp\hrps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\htp\htpt\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lanc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\lan\lans\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\paspc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\pasp\pasps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxm\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\prox\proxr\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\rscp\rscps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scppc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\scpp\scpps\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\suota\suotar\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tipc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\tip\tips\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udsc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\uds\udss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wssc\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\profiles\wss\wsss\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\ble_stack\rwble_hl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\boot\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\ARM;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\compiler\GCC;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\ll;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\arch\main;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\arch_console;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\common\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\crypto;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\dbg\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\gtl\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\h4tl\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\ke\src;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\nvds\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rf\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\core_modules\rwip\api;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\adc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\battery;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\ble;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\dma;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\gpio;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\hw_otpc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\i2c_eeprom;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\pdm;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\reg;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\rtc;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\spi_flash;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\syscntl;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\systick;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\timer;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\trng;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\uart;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\driver\wkupct_quadec;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\include;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\system_library\include;C:\workspace\DA14531\test\6.0.12.1020\\third_party\hash;C:\workspace\DA14531\test\6.0.12.1020\\third_party\irng;C:\workspace\DA14531\test\6.0.12.1020\\third_party\rand;.\..\src;.\..\src\config;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_cs;C:\workspace\DA14531\test\6.0.12.1020\\sdk\platform\utilities\otp_hdr;..\..\..\portable;..\..\..\..\..\mijia_ble_libs\common;..\src\user;..\..\..\..\..\mijia_ble_libs;..\;..\..\..\..\..\..\mijia_ble_standard;..\src\custom_profile
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\workspace\DA14531\test\6.0.12.1020\\sdk\common_project_files\misc\da14531_symbols.txt   --symdefs=prox_reporter_531_symdef.txt --any_placement=best_fit --datacompressor off
