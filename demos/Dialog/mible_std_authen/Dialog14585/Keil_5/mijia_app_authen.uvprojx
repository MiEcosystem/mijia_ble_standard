# Keil uVision project mijia_app_authen.uvprojx, settings and files
target mijia_app_authen_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mijia_app_authen +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: CUSTOMIZED_MI_CONFIG_FILE=<custom_mi_config.h> MI_LOG_ENABLED MI_ASSERT
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\..\..\portable\sdk_overwriter;..\..\..\..\..\..\..\..\..\sdk\platform\include;..\..\..\..\..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_bass;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_diss;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_proxr;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_suotar;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\em;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\llc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\lld;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\llm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hcic;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hcih;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\attc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\attm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\atts;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;..\..\..\..\..\..\..\..\..\sdk\common_project_files;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\rwble;..\..\..\..\..\..\..\..\..\sdk\ble_stack\rwble_hl;..\..\..\..\..\..\..\..\..\sdk\ble_stack\ea\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\em\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hci\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hci\src;..\..\..\..\..\..\..\..\..\sdk\common_project_files;..\..\..\..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\..\..\..\sdk\platform\arch\boot\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\main;..\..\..\..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\arch_console;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\common\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\crypto;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\dbg\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\gtl\src;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\ke\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\ke\src;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\nvds\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\rf\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\rwip\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;..\..\..\..\..\..\..\..\..\sdk\platform\driver\adc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\battery;..\..\..\..\..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;..\..\..\..\..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\..\..\..\..\sdk\platform\driver\spi;..\..\..\..\..\..\..\..\..\sdk\platform\driver\spi_flash;..\..\..\..\..\..\..\..\..\sdk\platform\driver\syscntl;..\..\..\..\..\..\..\..\..\sdk\platform\driver\systick;..\..\..\..\..\..\..\..\..\sdk\platform\driver\trng;..\..\..\..\..\..\..\..\..\sdk\platform\driver\uart;..\..\..\..\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;..\..\..\..\..\..\..\..\..\sdk\platform\driver\ble;..\..\..\..\..\..\..\..\..\sdk\platform\driver\emi;..\..\..\..\..\..\..\..\..\sdk\platform\driver\intc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\hw_otpc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\dma;..\..\..\..\..\..\..\..\..\sdk\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\..\..\..\..\sdk\platform\system_library\include;..\..\..\..\..\..\..\..\..\third_party\rand;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\custom;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_custs;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\crypto;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;..\src\common;..\..\..\portable;..\src\user;..\..\..\..\..\mijia_ble_libs;..\..\..\..\..\..\mijia_ble_standard
  library: MicroLIB
  scatter file: ..\..\..\portable\sdk_overwriter\scatterfile_common.sct
  link misc: --feedback=".\unused_585.txt" .\..\..\..\..\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=prox_reporter_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ../../../../../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c
    ../../../../../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
    ../../../portable/sdk_overwriter/: boot_vectors.s
  group sdk_arch
    ../../../../../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ../../../../../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ../../../../../../../../../sdk/platform/arch/main/: arch_main.c arch_rom.c arch_sleep.c arch_system.c jump_table.c
    ../../../../../../../../../sdk/platform/system_library/output/Keil_5/: system_library.lib
    ../../../../../../../../../third_party/rand/: chacha20.c
  group sdk_driver
    ../../../../../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ../../../../../../../../../sdk/platform/driver/battery/: battery.c
    ../../../../../../../../../sdk/platform/driver/adc/: adc.c
    ../../../../../../../../../sdk/platform/driver/spi/: spi.c
    ../../../../../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../../../../../sdk/platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../../../../../sdk/platform/driver/trng/: trng.c
    ../../../../../../../../../sdk/platform/driver/uart/: uart2.c
  group sdk_ble
    ../../../../../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
    ../../../../../../../../../sdk/platform/core_modules/rf/src/: rf_585.c
    ../../../../../../../../../sdk/ble_stack/rwble/: rwble.c
  group sdk_profiles
    ../../../portable/sdk_overwriter/: prf.c
    ../../../../../../../../../sdk/ble_stack/profiles/: prf_utils.c
    ../../../../../../../../../sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../../../../../sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../../../../../sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../../../../../../../../../sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    ../../../../../../../../../sdk/ble_stack/host/att/attm/: attm_db_128.c
    ../../../../../../../../../sdk/ble_stack/profiles/custom/: custom_common.c
  group sdk_app
    ../../../../../../../../../sdk/app_modules/src/app_common/: app.c app_msg_utils.c app_task.c app_utils.c
    ../../../../../../../../../sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ../../../../../../../../../sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ../../../../../../../../../sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ../../../../../../../../../sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ../../../../../../../../../sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ../../../../../../../../../sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ../../../../../../../../../sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../../../../../sdk/app_modules/src/app_custs/: app_customs.c
    ../../../portable/sdk_overwriter/: app_entry_point.c app_default_handlers.c
  group sdk_crypto
    ../../../../../../../../../sdk/platform/core_modules/crypto/: aes.c aes_api.c aes_task.c sw_aes.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_app_authen.c
  group DA14585_mible_api
    ../../../portable/: app_mijia.c app_mijia_task.c cassert.c da14585_api.c easy_msg.c easy_nvds.c easy_timer.c mi_app_customs.c mi_attm_db_128.c mible_api.c mijia.c mijia_task.c sdk_supplement.c uart2_sync.c user_custs_config.c user_custs1_def.c user_default_handlers.c
  group mijia_ble_libs/standard_auth
    ../../../../../mijia_ble_libs/standard_auth/: mible_standard_auth.c
  group mijia_ble_libs/common
    ../../../../../mijia_ble_libs/common/: crc32.c mible_beacon.c mible_crypto.c mible_rxfer.c queue.c tlv.c
  group user
    ../src/user/: user_mijia_ble.c
  group user_sps
    ../../../portable/: app_sps.c app_sps_task.c sps.c sps_task.c
  group mijia_ble_libs/crypto
    ../../../../../mijia_ble_libs/cryptography/: mi_crypto.c mi_crypto_backend_mbedtls.c mi_crypto_backend_uECC.c
  group mijia_ble_libs/third_party
    ../../../../../mijia_ble_libs/third_party/mbedtls/: asn1parse.c ccm.c sha256_hkdf.c
    ../../../../../mijia_ble_libs/third_party/pt/: pt_misc.c
    ../../../../../mijia_ble_libs/third_party/micro-ecc/: micro_ecc_m0p_le.lib
  group mijia_ble_libs/mijia_profiles
    ../../../../../mijia_ble_libs/mijia_profiles/: mi_service_server.c stdio_service_server.c
target lib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: mijia_std_authen_keil_DA14585_1_1_2 +hex (library)
  c flags: Optim=2 uC99=1 wLevel=2
  c define: MI_LOG_ENABLED
  c misc: as above
  c include: ..\src\mible_app_authen\mijia_ble_api\sdk_overwriter;..\..\..\..\..\..\..\..\..\sdk\platform\include;..\..\..\..\..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_bass;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_diss;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_proxr;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_suotar;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\em;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\llc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\lld;..\..\..\..\..\..\..\..\..\sdk\ble_stack\controller\llm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hcic;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hcih;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\attc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\attm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\att\atts;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;..\..\..\..\..\..\..\..\..\sdk\common_project_files;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;..\..\..\..\..\..\..\..\..\sdk\ble_stack\host\smp;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\rwble;..\..\..\..\..\..\..\..\..\sdk\ble_stack\rwble_hl;..\..\..\..\..\..\..\..\..\sdk\ble_stack\ea\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\em\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hci\api;..\..\..\..\..\..\..\..\..\sdk\ble_stack\hci\src;..\..\..\..\..\..\..\..\..\sdk\common_project_files;..\..\..\..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\..\..\..\sdk\platform\arch\boot\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\..\..\..\..\sdk\platform\arch\main;..\..\..\..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\arch_console;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\common\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\crypto;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\dbg\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\gtl\src;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\ke\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\ke\src;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\nvds\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\rf\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\rwip\api;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;..\..\..\..\..\..\..\..\..\sdk\platform\driver\adc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\battery;..\..\..\..\..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;..\..\..\..\..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\..\..\..\..\sdk\platform\driver\spi;..\..\..\..\..\..\..\..\..\sdk\platform\driver\spi_flash;..\..\..\..\..\..\..\..\..\sdk\platform\driver\syscntl;..\..\..\..\..\..\..\..\..\sdk\platform\driver\systick;..\..\..\..\..\..\..\..\..\sdk\platform\driver\trng;..\..\..\..\..\..\..\..\..\sdk\platform\driver\uart;..\..\..\..\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;..\..\..\..\..\..\..\..\..\sdk\platform\driver\ble;..\..\..\..\..\..\..\..\..\sdk\platform\driver\emi;..\..\..\..\..\..\..\..\..\sdk\platform\driver\intc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\hw_otpc;..\..\..\..\..\..\..\..\..\sdk\platform\driver\dma;..\..\..\..\..\..\..\..\..\sdk\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\..\..\..\..\sdk\platform\system_library\include;..\..\..\..\..\..\..\..\..\third_party\rand;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\custom;..\..\..\..\..\..\..\..\..\sdk\app_modules\src\app_custs;..\..\..\..\..\..\..\..\..\sdk\platform\core_modules\crypto;..\..\..\..\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;..\src\common;..\..\..\..\..\libs\common;..\..\..\..\..\libs\mible_app_authen;..\..\..\portable
  library: MicroLIB
  scatter file: ..\..\..\portable\sdk_overwriter\scatterfile_common.sct
  link misc: as above
